require include/drpai/core-image-sdk.inc
require include/drpai/extend_packages.inc

TOOLCHAIN_TARGET_TASK_append = " drpai "