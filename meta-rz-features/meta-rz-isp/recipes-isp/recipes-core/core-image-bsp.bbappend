# ISP package install
IMAGE_INSTALL_append = " \
    kernel-modules \
    libmetal \
    open-amp \
    comctl \
"
