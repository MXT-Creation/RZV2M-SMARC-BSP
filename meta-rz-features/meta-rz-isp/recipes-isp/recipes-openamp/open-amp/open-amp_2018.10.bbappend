# 
# Copyright (C) 2021 eForce, Co, Ltd.
#

FILESEXTRAPATHS_prepend := "${THISDIR}/2018.10:"

SRC_URI += " \
    file://0001-virtqueue.h.patch \
" 
